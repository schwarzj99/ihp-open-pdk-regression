** sch_path: inductor/schematic/inmos.sch
**.subckt inmos A B C
*.iopin A
*.iopin B
*.iopin C
R1 net1 A 10m m=1
R2 net1 B 10m m=1
R3 net1 C 10m m=1
**.ends
.end
